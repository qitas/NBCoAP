# Keil uVision project Coap.uvprojx, settings and files
target STM32BC26 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -o./STM32BC26.bin ./BC26/Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\Libs\inc;..\Libs\startup\arm;..\user;..\NET;..\Proc;..\BSP;..\SYS;..\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h system_stm32f10x.c
  group BSP
    ../BSP/: bsp.c eum_uart.c
    ../NET/BC26/: BC26.c
  group Proc
    ../Proc/: mqttlib.c common.c
    ../Proc/JSON/: cJSON.c
    ../Proc/BASE64/: cbase64.c
  group SYS
    ../SYS/: wd.c adc.c mem.c flash.c utimer.c config.c bkpreg.c standby.c serialport.c RTC_Time.c
  group STlib
    ../Libs/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libs/startup/arm/: startup_stm32f10x_hd.s
  group Task
    ../OS/: task.c
software components: CMSIS:CORE 5.0.1
